options:
  parameters:
    author: valigatotuS
    description: 'Receive LoRa frames '
    generate_options: qt_gui
    id: LoRa_sdrrtl_receive
    output_language: python
    title: LoRa Receiver with RTL-SDR dongle
  states: {}

blocks:
- name: channel_freq
  id: variable_qtgui_entry
  parameters:
    label: Channel frequency
    type: real
    value: 868.1e6
  states: {}
- name: freq_slider
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: 867e6
    step: '1'
    stop: 869e6
    value: 868e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*4
    ctrlpanel: 'True'
    fc: freq_slider
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate*4
    fc: channel_freq
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    args: str(grgsm.device.get_default_args(args))
    bb_gain0: '0'
    bw0: 1e6
    freq0: freq_slider
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [rtlsdr_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
